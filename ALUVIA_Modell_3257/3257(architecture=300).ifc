Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_576/temp/tmp_1656_40_hbmbm/format_1/3257(architecture=300).ifc
Time: 2025-09-01T09:05:41
Made in: PARTsolutions

# IfcProject, 3257(architecture=300)
Description: ALUVIA

# IfcDiscreteAccessory, 3257(architecture=300)
In: BUILDING
Description: 3257(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 3257
ePset_PARTsolutions - NB: 3257(architecture=300); NN: 3257; NT: ALUVIA; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 3257(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 3257; B: 3257_aluvia_800x1200.png; C: ALUVIA; E: KALDEWEI; EF000049: 800; EF004567: 1200; etim7_EC003246: EC003246; etim7_EC003246_WIDTH: 1200; etim7_EC003246_LENGTH: 800
